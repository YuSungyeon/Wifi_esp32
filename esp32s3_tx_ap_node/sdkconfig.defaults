## esp32s3_tx_ap_node/sdkconfig.defaults
```kconfig
# CSI 샘플링: A-MPDU 집계로 인한 프레임 타이밍 지터 완화
CONFIG_ESP_WIFI_AMPDU_TX_ENABLED=n
CONFIG_ESP_WIFI_AMPDU_RX_ENABLED=n
```
